# Keil uVision project led_string.uvprojx, settings and files
target nolib (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led_string
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\source\nolib.sct
  group source
    ../source/: csp.c main.c max7219.c spi.c startup.c
target CMSIS_drv (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: led_string
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target CMSIS_without_drv (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: led_string
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS Driver:SPI:Custom 1.0.0, CMSIS:CORE 5.6.0, CMSIS Driver:SPI 2.2, Device:DMA 1.3, Device:GPIO 1.3, Device:Startup 1.0.0
